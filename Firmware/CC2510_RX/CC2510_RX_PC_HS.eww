<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CC2510_RX_PC_HS.ewp</path>
  </project>
  <batchBuild/>
</workspace>


